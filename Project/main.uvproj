# Keil uVision project main.uvproj, settings and files
target master_f103 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: main
  c flags: Optim=3 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\STLibrary\cm3;..\STLibrary\inc;..\STLibrary\src;..\Devices;..\Periph;..\Code
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ARMCore
    ../STLibrary/cm3/: core_cm3.c startup_stm32f10x_md.s
  group STLibrary
    ../STLibrary/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Periph
    ../Periph/: i2c.c sysTime.c uart.c
  group Device
    ../Devices/: at24c02.c buzz.c key.c lcd.c led.c r37.c
  group Code
    ../Code/: main.c stm32f10x_it.c system_stm32f10x.c
